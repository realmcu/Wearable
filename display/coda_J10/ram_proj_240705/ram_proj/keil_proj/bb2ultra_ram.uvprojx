# Keil uVision project bb2ultra_ram.uvprojx, settings and files
target TEST_ROM (6220000::V6.22::..\..\AC\622)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: before_build.bat && echo %TIME%
  AfterMake: after_build.bat $J #L @L @P && echo %TIME%
  c flags: Optim=7 uC99=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: IC_TYPE_BB2U
  c misc: -gdwarf-3 -mfpu=fpv5-sp-d16
  c include: .\;..\src\system_init\inc;..\Basic\inc;..\os\freertos\include;..\os\freertos\portable\GCC\ARM_CM33_NTZ;..\src\peripheral;..\autotest;..\manual_test;..\src\BB2_IO_driver\inc;..\src\hal_io;..\src\sd_mgr\config;..\src\sd_mgr\sd_lib;..\..\..\jpeg\jinc;..\..\..\jpeg\tlsf
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\app_rom.sct
  link misc: --diag_suppress=L6314,6480 --datacompressor off --no_remove
  group config
    ../Basic/inc/: hwtest_config.h
  group cmsis
    ../lib/: hal_utils.lib
    ../src/system_init/src/: bb2plus_platform.c system_bb2plus.c
    ../src/system_init/: vector_table.c startup_bb2plus.s vector_table_auto_gen.c
  group os
    ../os/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/freertos/portable/MemMang/: heap_4.c
    ../os/: freertos_test.c
    ../os/freertos/portable/GCC/ARM_CM33_NTZ/: port.c portasm.c
  group time_function
    ../Basic/src/: SystemTick.c time_adapter.c
    ../src/system_init/src/: bb2plus_timer.c
  group log function
    ../Basic/src/: log_adapter.c
    ../src/system_init/src/: bb2plus_uart.c
  group peripheral
    ../src/peripheral/: patch_iodriver.c rtl876x_gdma.c rtl876x_gpio.c rtl876x_nvic.c rtl876x_rcc.c rtl876x_tim.c rtl876x_uart.c spic_basic.c rtl876x_pinmux.c indirect_access.c platform_rtc.c boot_rom_func_ptr.c utils.c log.c rtl876x_uart_int.c rtl876x_gdma_int.c rtl876x_tim_int.c rtl876x_i2c.c rtl876x_i2c_int.c rtl876x_spi.c rtl876x_spi_int.c rtl876x_sleep_led.c rtl876x_gpio_int.c rtl876x_iso7816.c rtl876x_rtc.c rtl876x_qdec.c rtl876x_wdg.c rtl876x_lppwm.c rtl876x_keyscan.c rtl_can.c rtl876x_adc.c rtl876x_adc_int.c rtl876x_ir.c rtl876x_ir_int.c rtl_can_int.c rtl876x_lpc.c
  group main
    ../Basic/src/: main.c app_task.c
  group io_demo
    ../src/io_demo/gpio/output/: gpio_output_demo.c
    ../src/hal_io_src/common/: hal_gpio.c
    ../src/hal_io_src/rtl87x3e/: hal_gpio_int.c
    ../src/io_demo/sdio/sdcard/: sdio_demo.c
  group sd_mgr
    ../src/sd_mgr/sd_public/: sd.c
    ../src/sd_mgr/sd_lib/: mmc.c sd_if.c sd_os.c sdcard.c sdh_int.c sdh_prop.c sdh_pwr.c rtl876x_sdio.c
  group jpeg
    ../../../jpeg/jsrc/: jdi.c jpeg_decoder.c jpuapi.c jpuapifunc_rt.c jpuhelper_rt.c mixer.c jpeg_encoder.c arm_ahb_cache_ctrl.c
    ../../../jpeg/tlsf/: tlsf.c jpeg_heap.c
target TEST_RAM (6220000::V6.22::.\ARM_CLANG\ARMClang\ArmCompilerforEmbedded6.22)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: app
  BeforeMake: before_build.bat && echo %TIME%
  AfterMake: after_build.bat $J #L @L @P && echo %TIME%
  c flags: Optim=7 uC99=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: IC_TYPE_BB2
  c misc: -gdwarf-3 -mfpu=fpv5-sp-d16
  c include: .\;..\src\system_init\inc;..\Basic\inc;..\os\freertos\include;..\os\freertos\portable\GCC\ARM_CM33_NTZ;..\src\peripheral;..\autotest;..\manual_test;..\src\BB2_IO_driver\inc;..\src\hal_io;..\src\sd_mgr\config;..\src\sd_mgr\sd_lib
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\app_ram.sct
  link misc: --diag_suppress=L6314,6480 --datacompressor off --no_remove
